# Keil uVision project large_outlet_light_board.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: large_outlet_light_board +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Module\Inc;..\System\Inc
  group Source Group 1
    ../Module/Src/: ws2812.c
    ../System/Src/: main.c timer.c
