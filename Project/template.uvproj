# Keil uVision project template.uvproj, settings and files
target WS2812_Light_Board (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Module\Inc;..\System\Inc
  group System
    ../System/Src/: timer.c main.c
  group Module
    ../Module/Src/: ws2812.c
